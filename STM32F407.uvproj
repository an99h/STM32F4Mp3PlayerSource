# Keil uVision project STM32F407.uvproj, settings and files
target Mp3_player (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Mp3_player +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY,__FPU_PRESENT=0,
  c include: .\FATFS\inc;.\Hardware;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_HOST_Library\Core\inc;.\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\Libraries\STM32_USB_OTG_Driver\inc;.\Mp3Lib\inc;.\User;.\FLAC;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\SD;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\UCOSII\CORE;.\UCOSII\CONFIG;.\UCOSII\PORT;.\MALLOC;.\FATFS\exfuns;.\HARDWARE\AUDIOCODEC;.\CORE;.\Mp3Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./CORE/: startup_stm32f4xx.s
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c
    ./USER/: ProductTest.c
  group FWlib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FATFS
    ./FATFS/src/: fattime.c ff.c diskio.c
    ./FATFS/exfuns/: exfuns.c mycc936.c
  group HARDWARE
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/SD/: sd.c
    ./HARDWARE/AUDIOCODEC/: codec.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group MP3Lib
    ./Mp3Lib/src/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ./Mp3Lib/src/arm/: asmmisc.S asmpoly_thumb2.S
    ./Mp3Lib/: mp3play.c
  group USB-OTG
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB-HOST
    ./Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group UCOS-CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS-CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
